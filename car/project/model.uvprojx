# Keil uVision project model.uvprojx, settings and files
target deepseek (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: deepseek +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\FWlib\inc;..\Sys_Init\inc;..\system\inc;..\User_Driver\inc;..\User_Prog\inc;..\User_App\src;..\;..\User_Prog\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sys_Init
    ../Sys_Init/src/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Std_Driver
    ../FWlib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_exti.c
  group system
    ../system/src/: device_timer.c scheduler.c time.c
  group User_Driver
    ../User_Driver/src/: motor.c tracker.c pwm.c
  group User_Prog
    ../User_Prog/src/: pid.c car_drive.c
  group User_App
    ../User_App/src/: main.c
